# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blood_Oxygen_Instrument +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\User\SysTick;..\User\TimBase;..\User\usart;..\User\BSP_ADC;..\User\LCD;..\User\TOUCH;..\User\test;..\User\sys;..\User\IIC;..\User\delay;..\User\tempurature;..\User\IIC_simulation;..\User\UI;..\User\boot_picture;..\User\ESP01S
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\Template.sct
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/usart/: bsp_usart.c
    ../User/TimBase/: bsp_TiMbase.c
    ../User/SysTick/: bsp_SysTick.c
    ../User/BSP_ADC/: bsp_adc.c
    ../User/LCD/: GUI.c lcd.c
    ../User/TOUCH/: touch.c
    ../User/sys/: sys.c
    ../User/delay/: delay.c
    ../User/test/: test.c
    ../User/tempurature/: temperature.c
    ../User/IIC_simulation/: algorithm.c max30102.c myiic.c
    ../User/UI/: ui.c key.c
    ../User/boot_picture/: boot_picture.c
    ../User/ESP01S/: esp01s.c
  group DOC
    ../Doc/: readme.txt
